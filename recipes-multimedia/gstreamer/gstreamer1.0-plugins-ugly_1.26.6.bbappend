PACKAGECONFIG:remove:imx-nxp-bsp = "a52dec mpeg2dec"
