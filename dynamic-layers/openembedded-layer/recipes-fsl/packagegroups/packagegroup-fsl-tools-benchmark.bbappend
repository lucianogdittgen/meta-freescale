RDEPENDS:${PN}:append = " bonnie++ dbench fio iozone3 iperf3 lmbench nbench-byte tiobench"
